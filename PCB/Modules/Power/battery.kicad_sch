File: PCB/Modules/Power/battery.kicad_sch (KiCad schematic)
At the start: 2 parts

Commit message: Update to KiCad 10.
Parts:
- BT1, BT2: value ~ -> (none)
